options:
  parameters:
    author: MB
    generate_options: qt_gui
    id: hrpt_mteor_decoder
    output_language: python
    title: HRPT METEOR Decoder
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1700e6
  states: {}
- name: clock_alpha
  id: variable_qtgui_range
  parameters:
    label: Clock Alpha
    min_len: '150'
    orient: Qt.Horizontal
    start: '1e-3'
    step: '1e-5'
    stop: '50e-3'
    value: '40e-3'
  states: {}
- name: hs
  id: variable
  parameters:
    value: int(sps/2.0)
  states: {}
- name: pll_alpha
  id: variable_qtgui_range
  parameters:
    label: PLL Alpha
    min_len: '150'
    orient: Qt.Horizontal
    start: '0.00100'
    step: '0.00001'
    stop: '0.10000'
    value: '0.030'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: (samp_rate*1.0)/(symbol_rate*1.0)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 600*1109
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: 0.5/32768.0
    max_gain: '5000'
    rate: '0.0038e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc_xx_0_0_0
  id: analog_agc_xx
  parameters:
    gain: 0.5/32768.0
    max_gain: '3000'
    rate: '0.000030e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.08'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    repeat: 'False'
    type: short
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: hs
    max_iter: '4000'
    scale: 1.0/hs
    type: float
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: clock_alpha
    gain_omega: clock_alpha**2/4.0
    mu: '1.0'
    omega: sps/2.0
    omega_relative_limit: max_clock_offset
    type: float
  states: {}
- name: frames_file_sink
  id: blocks_file_sink
  parameters:
    file: /home/alan/Downloads/mn2.raw16
    type: byte
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: symbol_rate * 2
    decim: '2'
    gain: '1'
    samp_rate: samp_rate*2
    type: fir_filter_ccf
    width: 100e3
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: max_carrier_offset
  id: parameter
  parameters:
    label: MaxCarrierOffset
    type: eng_float
    value: '0.50'
  states: {}
- name: max_clock_offset
  id: parameter
  parameters:
    label: MaxClockOffset
    type: eng_float
    value: '0.01'
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: RTLSDR
  states: {state: disabled}
- name: osmosdr_source_0_1
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '40'
    dc_offset_mode0: '2'
    freq0: center_freq
    gain0: '40'
    gain_mode0: 'True'
    if_gain0: '40'
    iq_balance_mode0: '1'
    sample_rate: samp_rate*2
    sync: sync
    type: fc32
  states: {state: disabled}
- name: pll
  id: noaa_hrpt_pll_cf
  parameters:
    alpha: pll_alpha
    beta: pll_alpha**2/4.0
    max_offset: max_carrier_offset
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"dark red"'
    grid: 'True'
    label1: '10'
    name: Output Constellation
    size: '2048'
    type: complex
    update_time: '0.05'
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    update_time: '0.03'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-100'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.4'
    decim: '1'
    gain: '1'
    ntaps: '361'
    samp_rate: samp_rate
    sym_rate: symbol_rate*2.2
    type: fir_filter_ccf
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: bb_input
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: synced_symbols
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: bb_input
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: synced_symbols
  states: {}

connections:
- [analog_agc_xx_0, '0', root_raised_cosine_filter_0, '0']
- [analog_agc_xx_0_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [analog_noise_source_x_0, '0', blocks_float_to_complex_1, '1']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_float_to_complex_1, '0', analog_agc_xx_0_0_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', virtual_sink_0_0, '0']
- [blocks_moving_average_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', frames_file_sink, '0']
- [digital_binary_slicer_fb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_float_to_complex_1, '0']
- [digital_clock_recovery_mm_xx_0, '0', virtual_sink_1, '0']
- [osmosdr_source_0_1, '0', low_pass_filter_0_1, '0']
- [pll, '0', blocks_moving_average_xx_0, '0']
- [root_raised_cosine_filter_0, '0', pll, '0']
- [root_raised_cosine_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [virtual_source_0, '0', analog_agc_xx_0, '0']
- [virtual_source_1, '0', digital_binary_slicer_fb_0, '0']

metadata:
  file_format: 1
