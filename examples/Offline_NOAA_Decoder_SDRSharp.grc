options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: hrpt_noaa_decoder
    output_language: python
    run_options: run
    title: HRPT NOAA Decoder
  states: {}

blocks:
- name: clock_alpha_0
  id: variable_qtgui_range
  parameters:
    label: Clock Alpha
    min_len: '150'
    orient: Qt.Horizontal
    start: '1e-3'
    step: '1e-5'
    stop: '50e-3'
    value: '40e-3'
  states: {}
- name: hs
  id: variable
  parameters:
    value: int(sps/2.0)
  states: {}
- name: max_carrier_offset
  id: variable
  parameters:
    value: 3*math.pi*100e3/sample_rate
  states: {}
- name: max_clock_offset
  id: variable
  parameters:
    value: '100e-6'
  states: {}
- name: pll_alpha_0
  id: variable_qtgui_range
  parameters:
    label: PLL Alpha
    min_len: '150'
    orient: Qt.Horizontal
    start: '0.00100'
    step: '0.00001'
    stop: '0.10000'
    value: '0.030'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: sample_rate/sym_rate
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: 600*1109
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: 0.5/32768.0
    max_gain: '4000'
    rate: '0.002e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: 0.5/32768.0
    max_gain: '3000'
    rate: '0.000030e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.08'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: short
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    repeat: 'False'
    type: short
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: hs
    max_iter: '4000'
    scale: 1.0/hs
    type: float
  states: {}
- name: clock_alpha
  id: parameter
  parameters:
    label: clock_alpha
    short_id: s
    type: eng_float
    value: '0.01'
  states: {}
- name: decim
  id: parameter
  parameters:
    label: decim
    short_id: d
    type: intx
    value: '32'
  states: {}
- name: decoder
  id: noaa_hrpt_decoder
  parameters:
    output: 'False'
    verbose: 'True'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: clock_alpha
    gain_omega: clock_alpha**2/4.0
    mu: '0.5'
    omega: sps/2.0
    omega_relative_limit: max_clock_offset
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math, os
  states: {}
- name: max_carrier_offset_0
  id: parameter
  parameters:
    label: MaxCarrierOffset
    type: eng_float
    value: '0.5'
  states: {}
- name: max_clock_offset_0
  id: parameter
  parameters:
    label: MaxClockOffset
    type: eng_float
    value: '0.01'
  states: {}
- name: noaa_hrpt_deframer_0
  id: noaa_hrpt_deframer
  parameters: {}
  states: {}
- name: pll
  id: noaa_hrpt_pll_cf
  parameters:
    alpha: pll_alpha
    beta: pll_alpha**2/4.0
    max_offset: max_carrier_offset
  states: {}
- name: pll_alpha
  id: parameter
  parameters:
    label: pll_alpha
    short_id: p
    type: eng_float
    value: '0.01'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"Dark Blue"'
    grid: 'True'
    label1: '30'
    marker1: '1'
    name: Output Constellation
    size: '2048'
    type: complex
    update_time: '0.02'
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    update_time: '0.03'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-100'
  states: {}

connections:
- [analog_agc_xx_0, '0', pll, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_agc_xx_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [analog_noise_source_x_0, '0', blocks_float_to_complex_1, '1']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_float_to_complex_1, '0', analog_agc_xx_0_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', analog_agc_xx_0, '0']
- [blocks_moving_average_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', noaa_hrpt_deframer_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_float_to_complex_1, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [noaa_hrpt_deframer_0, '0', blocks_file_sink_0, '0']
- [noaa_hrpt_deframer_0, '0', decoder, '0']
- [pll, '0', blocks_moving_average_xx_0, '0']

metadata:
  file_format: 1
